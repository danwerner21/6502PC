# Repository danwerner21/6502PC (continued)

## KiCad design 6502PC-6U.kicad_pcb (continued)

Schematic: ACIA.kicad_sch, 6502PC

Parts:
C61, C63, C64, C65, C66: 1.0 uF; STD_DDW_PCAP
C62: 0.1 uF; STD_DDW_CAP
J11: TTL SERIAL CONSOLE; STD_DDW_PINHEAD_V_1x06
J12: TTL CONSOLE PWR; STD_DDW_PINHEAD_V_1x02
JP3: JUMPER; STD_DDW_PINHEAD_V_1x02
P17: 1.8432 MHz CLK; STD_DDW_DIP14
P18: SERIAL; STD_DDW_PINHEAD_V_2x05
R4, R7: 4.7K; STD_DDW_RESISTOR
R5, R6: 1000; STD_DDW_RESISTOR
U48: G65SC51P; STD_DDW_DIP28
U49: MAX232; STD_DDW_DIP16

Connections:
+5V: C62.1, C64.1, C66.2, J12.1, P17.14, R4.1, R7.1, U48.15 (VCC), U49.16 (VCC); also elsewhere on the board
ACIA_CLK: P17.8, P17.9, P17.10, P17.11, U48.6 (XTAL1)
CTS: JP3.2 (B), P18.6, U49.13 (R1IN)
CTS_TTL: J11.6, U48.9 (~CTS), U49.9 (R2OUT), U49.12 (R1OUT)
DCD: R6.2, U48.16 (~DCD)
DSR: R5.2, U48.17 (~DSR)
DTR: R7.2, U48.11 (~DTR)
E: U48.27 (ϕ2); also elsewhere on the board
GND: C62.2, C64.2, C65.1, J11.1, P17.4, P17.5, P17.6, P17.7, P18.9, R5.1, R6.1, U48.1 (VSS), U49.15 (GND); also elsewhere on the board
unnamed: J11.3, J12.2
unnamed: JP3.1 (A), R4.2
unnamed: C61.1, U49.1 (C1+)
unnamed: C61.2, U49.3 (C1-)
unnamed: C63.1, U49.4 (C2+)
unnamed: C63.2, U49.5 (C2-)
unnamed: C66.1, U49.2 (VS+)
unnamed: C65.2, U49.6 (VS-)
RTS: P18.4, U49.14 (T1OUT)
RTS_TTL: J11.2, U48.8 (~RTS), U49.11 (T1IN)
RXD: P18.3, U49.8 (R2IN)
RXD_TTL: J11.4, U48.12 (RxD)
R/W: U48.28 (R/~W); also elsewhere on the board
TXD: P18.5, U49.7 (T2OUT)
TXD_TTL: J11.5, U48.10 (TxD), U49.10 (T2IN)
mA0: U48.13 (RS0); also elsewhere on the board
mA1: U48.14 (RS1); also elsewhere on the board
mA2: U48.2 (CS1); also elsewhere on the board
mD0: U48.18 (D0); also elsewhere on the board
mD1: U48.19 (D1); also elsewhere on the board
mD2: U48.20 (D2); also elsewhere on the board
mD3: U48.21 (D3); also elsewhere on the board
mD4: U48.22 (D4); also elsewhere on the board
mD5: U48.23 (D5); also elsewhere on the board
mD6: U48.24 (D6); also elsewhere on the board
mD7: U48.25 (D7); also elsewhere on the board
/IOSEL-0EF80: U48.3 (~CS2); also elsewhere on the board
/IRQ: U48.26 (~IRQ); also elsewhere on the board

Notes on the sheet:
CTS is an inverted signal on the RS-232 port. So it is really /CTS. To assert the signal, it must be tied to SPACE, which is a + RS-232 voltage. (MARK, or true, is a - RS-232 voltage.)

Schematic: RTC.kicad_sch, 6502PC

Parts:
C59, C60: 15pf; STD_DDW_CAP
D3, D4: D; STD_DDW_DIODE
P16: CONN_4; STD_DDW_PINHEAD_V_1x04
U47: M6242; STD_DDW_DIP18
X1: RTC_OSC; DDW_STD_RTCCRYSTAL

Connections:
+5V: D3.2 (A); also elsewhere on the board
BUSALE: U47.3 (ALE); also elsewhere on the board
CPU_/RD: U47.8 (RD); also elsewhere on the board
CPU_/WR: U47.10 (WR); also elsewhere on the board
GND: P16.2, P16.3, P16.4, U47.9 (GND); also elsewhere on the board
unnamed: C59.1, C60.1, D3.1 (K), D4.1 (K), U47.18 (VCC)
unnamed: D4.2 (A), P16.1
unnamed: C59.2, U47.17 (XT1), X1.2
unnamed: C60.2, U47.16 (XT), X1.1
PULLUP1: U47.15 (CS1); also elsewhere on the board
mA0: U47.4 (A0); also elsewhere on the board
mA1: U47.5 (A1); also elsewhere on the board
mA2: U47.6 (A2); also elsewhere on the board
mA3: U47.7 (A3); also elsewhere on the board
mD0: U47.14 (D0); also elsewhere on the board
mD1: U47.13 (D1); also elsewhere on the board
mD2: U47.12 (D2); also elsewhere on the board
mD3: U47.11 (D3); also elsewhere on the board
/IOSEL-0EF90: U47.2 (CS0); also elsewhere on the board

Notes on the sheet:
External Battery connector (2.5-3.6v) or soldered Super Cap 0.1-1.0 Farad (e.g., Jameco 142949, 0.22F)
SCap1

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
Board: 2 copper layers, 166 parts (0 on the bottom side), 261 nets, no tracks yet.
